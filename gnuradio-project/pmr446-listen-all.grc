options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: PMR446 - Listen ALL
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '3'
  states: {}
- name: filtre
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '2500'
    low_cutoff_freq: '-2500'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-30'
  states: {}
- name: audio_sink_2
  id: audio_sink
  parameters:
    device_name: default
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '8'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '31250'
    decim: decimation
    samp_rate: samp_rate
    taps: filtre
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '6250'
    decim: decimation
    samp_rate: samp_rate
    taps: filtre
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '18750'
    decim: decimation
    samp_rate: samp_rate
    taps: filtre
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '43750'
    decim: '3'
    samp_rate: samp_rate
    taps: filtre
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_2_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '56250'
    decim: decimation
    samp_rate: samp_rate
    taps: filtre
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_2_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '68750'
    decim: decimation
    samp_rate: samp_rate
    taps: filtre
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_2_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '81250'
    decim: decimation
    samp_rate: samp_rate
    taps: filtre
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_2_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '93750'
    decim: decimation
    samp_rate: samp_rate
    taps: filtre
    type: ccc
  states: {}
- name: network_tcp_sink_1
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '12345'
    type: short
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    comment: |-
      The PMR446 walkie-talkies use specific frequencies for their 8 main channels.  
      Here are the frequencies associated with each channel:

      Channel 1: 446.00625 MHz  
      Channel 2: 446.01875 MHz  
      Channel 3: 446.03125 MHz  
      Channel 4: 446.04375 MHz  
      Channel 5: 446.05625 MHz  
      Channel 6: 446.06875 MHz  
      Channel 7: 446.08125 MHz  
      Channel 8: 446.09375 MHz  

      These frequencies are standardized for PMR446 devices in Europe, 
      ensuring compatibility between different models and brands 
      of walkie-talkies using this standard.
    note: PMR 446
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '0'
    bw0: 10e3
    corr0: '-6.7'
    freq0: 446e6
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: 446e6
    fftsize: '256'
    grid: 'True'
    type: complex
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_add_xx_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_add_xx_0, '2']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_add_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', blocks_add_xx_0, '1']
- [freq_xlating_fir_filter_xxx_0_2, '0', blocks_add_xx_0, '3']
- [freq_xlating_fir_filter_xxx_0_2_0, '0', blocks_add_xx_0, '4']
- [freq_xlating_fir_filter_xxx_0_2_0_0, '0', blocks_add_xx_0, '5']
- [freq_xlating_fir_filter_xxx_0_2_0_0_0, '0', blocks_add_xx_0, '6']
- [freq_xlating_fir_filter_xxx_0_2_0_0_0_0, '0', blocks_add_xx_0, '7']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_2, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_2_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_2_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_2_0_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_2_0_0_0_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
