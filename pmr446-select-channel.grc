options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: PMR446 - select channel
  states: {}

blocks:
- name: channel
  id: variable_qtgui_chooser
  parameters:
    label: Choose your channel
    labels: '["Channel 1","Channel 2","Channel 3","Channel 4","Channel 5","Channel 6","Channel 7","Channel 8"]'
    num_opts: '0'
    options: '[1, 2, 3, 4, 5, 6, 7, 8]'
    type: int
    value: '1'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '3'
  states: {}
- name: filtre
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '2500'
    low_cutoff_freq: '-2500'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: myFrequencyCorrection
  id: variable
  parameters:
    value: '-6.7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: '-30'
    type: complex
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-30'
  states: {state: disabled}
- name: audio_sink_1
  id: audio_sink
  parameters:
    device_name: default
    samp_rate: '16000'
  states: {}
- name: audio_sink_2
  id: audio_sink
  parameters:
    device_name: default
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /tmp/testchildren.wav
    format: FORMAT_WAV
    samp_rate: '16000'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (12500*channel)-6250
    decim: decimation
    samp_rate: samp_rate
    taps: filtre
    type: ccc
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '12345'
    type: short
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The PMR446 walkie-talkies use specific frequencies for their 8 main channels.  
      Here are the frequencies associated with each channel:

      Channel 1: 446.00625 MHz  
      Channel 2: 446.01875 MHz  
      Channel 3: 446.03125 MHz  
      Channel 4: 446.04375 MHz  
      Channel 5: 446.05625 MHz  
      Channel 6: 446.06875 MHz  
      Channel 7: 446.08125 MHz  
      Channel 8: 446.09375 MHz  

      These frequencies are standardized for PMR446 devices in Europe, 
      ensuring compatibility between different models and brands 
      of walkie-talkies using this standard.
    note: PMR 446
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '0'
    bw0: 10e3
    corr0: myFrequencyCorrection
    freq0: 446e6
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: 446e6
    fftsize: '256'
    grid: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_float_to_short_0, '0', blocks_null_sink_0, '0']
- [blocks_float_to_short_0, '0', network_tcp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_2, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_1, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
